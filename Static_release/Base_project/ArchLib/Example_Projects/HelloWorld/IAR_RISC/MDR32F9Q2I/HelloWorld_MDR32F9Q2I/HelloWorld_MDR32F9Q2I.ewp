# IAR project HelloWorld_MDR32F9Q2I.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F9Q2I Milandr MDR32F9Q2I
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_MDR32F9Q2I
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR32FxQI\CoreSupport\CM3; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\inc; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\startup; ..\..\Libraries\SPL\MDR32FxQI\inc; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_1986VE92.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: HelloWorld_1986VE92.hex
  group Drivers
    ../../Libraries/SPL/MDR32FxQI/src/: MDR32FxQI_port.c MDR32FxQI_rst_clk.c
  group src
    ./: main.c
  group Startup
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/startup/iar/: startup_MDR32F9Q2I.S
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/startup/: system_MDR32F9Q2I.c system_MDR32F9Q2I.h
