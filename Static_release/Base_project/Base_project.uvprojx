# Keil uVision project Base_project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Base_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_MDR32F9Q2I
  c include: .\CMSIS\MDR32FxQI\CoreSupport\CM3;.\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\inc;.\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\startup\arm;.\config;.\inc;.\inc\USB_Library;.\inc\IRQ_Handler_Template;.\src;.\src\IRQ_Handler_Template;.\src\USB_Library;..\ProjectMilandr;.\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\startup
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group CMSIS
    ./CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/inc/: MDR32F9Q2I.h
    ./CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/startup/arm/: startup_MDR32F9Q2I.S
    ./CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/startup/: system_MDR32F9Q2I.c system_MDR32F9Q2I.h
    ./CMSIS/MDR32FxQI/CoreSupport/CM3/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group StdPeriph
    ./inc/: MDR32FxQI_adc.h MDR32FxQI_audio.h MDR32FxQI_bkp.h MDR32FxQI_can.h MDR32FxQI_comp.h MDR32FxQI_dac.h MDR32FxQI_dma.h MDR32FxQI_dsp.h MDR32FxQI_ebc.h MDR32FxQI_eeprom.h MDR32FxQI_eth.h MDR32FxQI_i2c.h MDR32FxQI_iwdg.h MDR32FxQI_port.h MDR32FxQI_power.h MDR32FxQI_rst_clk.h MDR32FxQI_sdio.h MDR32FxQI_ssp.h MDR32FxQI_timer.h MDR32FxQI_uart.h MDR32FxQI_usb.h MDR32FxQI_utils.h MDR32FxQI_wwdg.h
    ./src/: MDR32FxQI_adc.c MDR32FxQI_asm.S MDR32FxQI_audio.c MDR32FxQI_bkp.c MDR32FxQI_can.c MDR32FxQI_comp.c MDR32FxQI_dac.c MDR32FxQI_dma.c MDR32FxQI_dsp.c MDR32FxQI_ebc.c MDR32FxQI_eeprom.c MDR32FxQI_eth.c MDR32FxQI_i2c.c MDR32FxQI_iwdg.c MDR32FxQI_port.c MDR32FxQI_power.c MDR32FxQI_rst_clk.c MDR32FxQI_sdio.c MDR32FxQI_ssp.c MDR32FxQI_timer.c MDR32FxQI_uart.c MDR32FxQI_usb.c MDR32FxQI_utils.c MDR32FxQI_wwdg.c
    ./src/IRQ_Handler_Template/: MDR32F9Q2I_IT.c
    ./inc/IRQ_Handler_Template/: MDR32F9Q2I_IT.h
software components: CMSIS:CORE 5.6.0
