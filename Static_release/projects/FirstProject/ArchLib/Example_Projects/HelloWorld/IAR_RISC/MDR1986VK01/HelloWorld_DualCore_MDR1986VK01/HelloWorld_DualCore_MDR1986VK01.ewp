# IAR project HelloWorld_DualCore_MDR1986VK01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VK01 Milandr MDR1986VK01
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\MDR1986VK01\CoreSupport; ..\..\Libraries\CMSIS\MDR1986VK01\DeviceSupport\inc; ..\..\Libraries\CMSIS\MDR1986VK01\DeviceSupport\startup; ..\..\Libraries\SPL\MDR1986VK01\inc; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../Libraries/SPL/MDR1986VK01/src/: MDR1986VK01_port.c
  group src
    ./: main.c mutex.s
  group Startup
    ../../Libraries/CMSIS/MDR1986VK01/DeviceSupport/startup/iar/: startup_MDR1986VK01_DC.s
    ../../Libraries/CMSIS/MDR1986VK01/DeviceSupport/startup/: system_MDR1986VK01.c system_MDR1986VK01.h
